		.DATA
	A: .WORD 6666
	SUM:.WORD 0
		.TEXT
	LDR R5,=A
	LDR R0,[R5]
	MOV R2,#0 ;final answer
	MOV R3,#0
	MOV R4,#0
LOOP:
	MOV R4,#0
DI:
	CMP RO,#10
	BMI FINISH
	SUB R0,R0,#10
	ADD R4,R4,#1
	B DI
FINISH:
	MOV R3,R0
	ADD R2,R2,R3
	MOV R0,R4
	CMP R0,#0
	BNE LOOP
	B EXIT
EXIT:
	LDR R9,=SUM
	STR R2,[R9]
	SWI 0X011
